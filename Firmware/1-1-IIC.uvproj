# Keil uVision project 1-1-IIC.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 1-1-IIC +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\1-1-IIC
  group Source Group 1
    ./: main.c send.c send.h IIC.c IIC.h
